Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-16T13:30:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180216_1515(x64) - Exporter 19.0.0.405 - Alternate UI 19.0.0.405
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 16 13:30:37 2021 * Host: LAPTOP-N19464JH * Database: C:\Users\RAMIZS~1\AppData\Local\Temp\{CDB4ECFE-FC28-49ED-AEE5-88A6B92DD444}\ifc * Database version: 5507 * Database creation date: Tue Nov 16 13:30:36 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 16 13:30:36 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 16 13:30:36 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcFurnishingElement: REVIT_TBE244, REVIT_TBE244:REVIT_TBE244:18284
In: Level 1
Type - ElementType: REVIT_TBE244; Classification: E2020200 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: B&B Italia
